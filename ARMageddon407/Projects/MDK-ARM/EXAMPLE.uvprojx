# Keil uVision project EXAMPLE.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARM_comp5)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F407 +hex
  AfterMake: E:\STM32F407_Creat\EXAMPLE\Projects\MDK-ARM\keil5_disp_size_bar.exe
  AfterMake: fromelf.exe --bin -o ..\..\Projects\MDK-ARM\Output\F407.bin ..\..\Projects\MDK-ARM\Output\F407.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,STM32F407xx,USE_USB_FS,ARM_MATH_DSP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\SYSTEM\usart;..\..\Drivers\SYSTEM\delay;..\..\Drivers\SYSTEM\sys;..\..\Middlewares;..\..\Middlewares\DSP\Include;..\..\Middlewares\FreeRTOS;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM4_MPU;..\..\Middlewares\FreeRTOS_APP;..\..\Middlewares\MALLOC;..\..\Middlewares\USB\STM32_USB_Device_Library\Core\Inc;..\..\Middlewares\USB\STM32_USB_Device_Library\Class\CDC\Inc;..\..\Middlewares\USB\USB_APP;..\..\Middlewares\FATFS\exfuns;..\..\Middlewares\FATFS\source;..\..\Middlewares\AI;..\..\Drivers\BSP\LED;..\..\Drivers\BSP\CAN;..\..\Drivers\BSP\LCD;..\..\Drivers\BSP\DMA;..\..\Drivers\BSP\ADC;..\..\Drivers\BSP\DHT11;..\..\Drivers\BSP\NORFLASH;..\..\Drivers\BSP\SDIO;..\..\Drivers\BSP\SRAM;..\..\App
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/ADC/: adc.c
    ../../Drivers/BSP/CAN/: can.c
    ../../Drivers/BSP/DMA/: dma.c
    ../../Drivers/BSP/DHT11/: dht11.c
    ../../Drivers/BSP/NORFLASH/: norflash.c
    ../../Drivers/BSP/SDIO/: sdio_sdcard.c
    ../../Drivers/BSP/SRAM/: sram.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_can.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_ll_sdmmc.c
  group Middlewares/Freertos_Config
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM4_MPU/: port.c
  group Middlewares/Freertos_App
    ../../Middlewares/FreeRTOS_APP/: freertos_START.c Led_task.c Key_Task.c AI_Task.c Can_task.c Data_Save_task.c Ex_Temp_Humit_Task.c Light_Task.c
  group Middlewares/Malloc
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/Dsp
    ../../Middlewares/DSP/Lib/ARM/: arm_cortexM4lf_math.lib
  group Middlewares/USB
    ../../Middlewares/USB/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
    ../../Middlewares/USB/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../Middlewares/USB/USB_APP/: usbd_conf.c usbd_desc.c usbd_cdc_interface.c
  group Middlewares/FATFs
    ../../Middlewares/FATFS/exfuns/: exfuns.c fattester.c
    ../../Middlewares/FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c
  group Middlewares/AI
    ../../Middlewares/MODE/: Mode.c model_weights.c
  group App
    ../../App/: Can_App.c Data_Save.c Key_App.c Led_App.c Ex_Temp_Humit.c Light_App.c
  group Readme
    ../../: readme.txt
