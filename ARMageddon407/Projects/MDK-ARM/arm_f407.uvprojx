# Keil uVision project arm_f407.uvprojx, settings and files
target emWin (6180000::V6.18::ARMCLANG)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  AfterMake: E:\STM32F407_Creat\ARMageddon407\keil5_disp_size_bar.exe
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32F4xx,USE_HAL_DRIVER,ARM_MATH_DSP,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\DSP\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\GCC\ARM_CM4F;..\..\Middlewares\emWin\Config;..\..\Middlewares\emWin\emWin_Demo;..\..\Middlewares\emWin\inc;..\..\Middlewares\CMSIS_NN\Include\Internal;..\..\Middlewares\CMSIS_NN\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c freertos_demo.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/SRAM/: sram.c
    ../../Drivers/BSP/TIMER/: btim.c
    ../../Drivers/BSP/TOUCH/: touch.c
  group Drivers/DSP
    ../../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Middlewares/MALLOC
    ../../Middlewares/MALLOC/: malloc.c
  group Middlewares/FreeRTOS_CORE
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group Middlewares/emWin/Config
    ../../Middlewares/emWin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf.c
  group Middlewares/emWin/Lib
    ../../Middlewares/emWin/Lib/: GUI_CM4F_L.lib
  group Middlewares/emWin/emWin_APP
    ../../Middlewares/emWin/emWin_Demo/: GUIDEMO.c
  group Middlewares/emWin/OS
    ../../Middlewares/emWin/OS/: GUI_X_FreeRTOS.c
  group Middlewares/Cmisi_NN
    ../../Middlewares/CMSIS_NN/Source/ConvolutionFunctions/: arm_convolve_1_x_n_s4.c arm_convolve_1_x_n_s8.c arm_convolve_1x1_s4.c arm_convolve_1x1_s4_fast.c arm_convolve_1x1_s8.c arm_convolve_1x1_s8_fast.c arm_convolve_even_s4.c arm_convolve_get_buffer_sizes_s4.c arm_convolve_get_buffer_sizes_s8.c arm_convolve_get_buffer_sizes_s16.c arm_convolve_s4.c arm_convolve_s8.c arm_convolve_s16.c arm_convolve_wrapper_s4.c arm_convolve_wrapper_s8.c arm_convolve_wrapper_s16.c arm_depthwise_conv_3x3_s8.c arm_depthwise_conv_fast_s16.c arm_depthwise_conv_get_buffer_sizes_s4.c arm_depthwise_conv_get_buffer_sizes_s8.c arm_depthwise_conv_get_buffer_sizes_s16.c arm_depthwise_conv_s4.c arm_depthwise_conv_s4_opt.c arm_depthwise_conv_s8.c arm_depthwise_conv_s8_opt.c arm_depthwise_conv_s16.c arm_depthwise_conv_wrapper_s4.c arm_depthwise_conv_wrapper_s8.c arm_depthwise_conv_wrapper_s16.c arm_nn_depthwise_conv_s8_core.c arm_nn_mat_mult_kernel_row_offset_s8_s16.c arm_nn_mat_mult_kernel_s4_s16.c arm_nn_mat_mult_kernel_s8_s16.c arm_nn_mat_mult_kernel_s16.c arm_nn_mat_mult_s8.c arm_transpose_conv_get_buffer_sizes_s8.c arm_transpose_conv_s8.c arm_transpose_conv_wrapper_s8.c
    ../../Middlewares/CMSIS_NN/Source/NNSupportFunctions/: arm_nn_depthwise_conv_nt_t_padded_s8.c arm_nn_depthwise_conv_nt_t_s4.c arm_nn_depthwise_conv_nt_t_s8.c arm_nn_depthwise_conv_nt_t_s16.c arm_nn_lstm_calculate_gate_s8_s16.c arm_nn_lstm_calculate_gate_s16.c arm_nn_lstm_step_s8.c arm_nn_lstm_step_s16.c arm_nn_mat_mul_core_1x_s4.c arm_nn_mat_mul_core_1x_s8.c arm_nn_mat_mul_core_4x_s8.c arm_nn_mat_mult_nt_interleaved_t_even_s4.c arm_nn_mat_mult_nt_t_s4.c arm_nn_mat_mult_nt_t_s8.c arm_nn_mat_mult_nt_t_s8_s32.c arm_nn_mat_mult_nt_t_s16.c arm_nn_transpose_conv_row_s8_s32.c arm_nn_vec_mat_mul_result_acc_s8_s16.c arm_nn_vec_mat_mul_result_acc_s16.c arm_nn_vec_mat_mult_t_per_ch_s8.c arm_nn_vec_mat_mult_t_s4.c arm_nn_vec_mat_mult_t_s8.c arm_nn_vec_mat_mult_t_s16.c arm_nn_vec_mat_mult_t_s16_s16.c arm_nn_vec_mat_mult_t_svdf_s8.c arm_nntables.c arm_q7_to_q15_with_offset.c arm_s8_to_s16_unordered_with_offset.c
    ../../Middlewares/CMSIS_NN/Source/FullyConnectedFunctions/: arm_batch_matmul_s8.c arm_batch_matmul_s16.c arm_fully_connected_get_buffer_sizes_s8.c arm_fully_connected_get_buffer_sizes_s16.c arm_fully_connected_per_channel_s8.c arm_fully_connected_s4.c arm_fully_connected_s8.c arm_fully_connected_s16.c arm_fully_connected_wrapper_s8.c arm_vector_sum_s8.c arm_vector_sum_s8_s64.c
    ../../Middlewares/CMSIS_NN/Source/PoolingFunctions/: arm_avgpool_get_buffer_sizes_s8.c arm_avgpool_get_buffer_sizes_s16.c arm_avgpool_s8.c arm_avgpool_s16.c arm_max_pool_s8.c arm_max_pool_s16.c
    ../../Middlewares/CMSIS_NN/Source/SoftmaxFunctions/: arm_nn_softmax_common_s8.c arm_softmax_s8.c arm_softmax_s8_s16.c arm_softmax_s16.c arm_softmax_u8.c
    ../../Middlewares/CMSIS_NN/Source/ActivationFunctions/: arm_nn_activation_s16.c arm_relu_q7.c arm_relu_q15.c arm_relu6_s8.c
    ../../Middlewares/CMSIS_NN/Source/BasicMathFunctions/: arm_elementwise_add_s8.c arm_elementwise_add_s16.c arm_elementwise_mul_acc_s16.c arm_elementwise_mul_s8.c arm_elementwise_mul_s16.c arm_elementwise_mul_s16_batch_offset.c arm_elementwise_mul_s16_s8.c arm_maximum_s8.c arm_minimum_s8.c
